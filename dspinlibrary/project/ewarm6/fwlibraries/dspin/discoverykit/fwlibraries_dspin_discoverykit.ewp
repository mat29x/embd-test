# IAR project fwlibraries_dspin_discoverykit.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xB ST STM32F105xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER; ST_DSPIN_6470H_DISCOVERY
  ICCARM.PreInclude: ..\..\..\..\..\dspin\inc\pre_include.h
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\stm32f10x\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\..\stm32f10x\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\dspin\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fwlibraries_dspin_discoverykit.hex
  ILINK.IlinkOutputFile: fwlibraries_dspin_discoverykit.out
  ILINK.IlinkIcfFile: config\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group stm32f10x/CMSIS
    ../../../../../../stm32f10x/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../../../../../../stm32f10x/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group stm32f10x/StdPeriph_Driver
    ../../../../../../stm32f10x/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
  group user/dspin
    ../../../../../dspin/src/: clock.c dspin.c main.c stm32f10x_it.c
